File: PCB.kicad_sch (KiCad schematic)
At the start: 18 parts

Commit message: change
Parts:
- gave numbers to parts that had none: 18
